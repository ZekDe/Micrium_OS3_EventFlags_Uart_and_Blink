# Keil uVision project new.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: new
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG, STM32F407xx, USE_FULL_LL_DRIVER, HSE_STARTUP_TIMEOUT=100, LSE_STARTUP_TIMEOUT=5000, LSE_VALUE=32768, EXTERNAL_CLOCK_VALUE=12288000, HSI_VALUE=16000000, LSI_VALUE=32000, VDD_VALUE=3300, PREFETCH_ENABLE=1, INSTRUCTION_CACHE_ENABLE=1, DATA_CACHE_ENABLE=1, HSE_VALUE=8000000
  c include: .\Network\src;.\Network\inc;..\MicriumFirstPort;.\STM32F4xx\src;.\STM32F4xx\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ./: main.c main.h gpio.h gpio.c stm32f4xx_it.c stm32f4xx_it.h micrium_port.s bsp.c bsp.h usart.c usart.h utility.c retarget.c
software components: CMSIS:CORE 5.5.0, Device:STM32Cube Framework:Classic 1.7.9, Device:STM32Cube LL:Common 1.7.9, Device:STM32Cube LL:EXTI 1.7.9, Device:STM32Cube LL:GPIO 1.7.9, Device:STM32Cube LL:PWR 1.7.9, Device:STM32Cube LL:RCC 1.7.9, Device:STM32Cube LL:USART 1.7.9, Device:STM32Cube LL:UTILS 1.7.9, Device:Startup 2.6.3, RTOS:uC/OS Common 1.0.0, RTOS:uC/OS Kernel 1.0.0
